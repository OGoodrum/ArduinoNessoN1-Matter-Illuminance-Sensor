## sdkconfig.defaults
```kconfig
CONFIG_BT_NIMBLE_HOST_TASK_STACK_SIZE=8192
CONFIG_CHIP_TASK_STACK_SIZE=8192
CONFIG_OPENTHREAD_THREAD_STACK_SIZE=4096
```
